# Keil uVision project My_OV_Watch.uvprojx, settings and files
target My_OV_Watch (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: My_OV_Watch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/LCD;../SYSTEM;../User/Soft_Timer;../User/WatchFace;../User/App;../User/Device;../User/Pages;../User/Power;../ThirdParty/LVGL/GUI;../ThirdParty/LVGL/GUI/lvgl;../ThirdParty/LVGL/GUI/lvgl/src;../ThirdParty/LVGL/GUI/porting;../BSP/TOUCH;../BSP/IIC;../BSP/KEY;../BSP/BL24C02;../BSP/AHT21;../BSP/EM7028;../BSP/LSM303DLH;../BSP/MPU6050;../BSP/POWER;../BSP/KT6328
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c adc.c gpio.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_ll_spi.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../BSP/LCD/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h lcd_fps_test.c
    ../BSP/TOUCH/: CST816.c
    ../BSP/IIC/: iic_hal.c
    ../BSP/KEY/: key.c
    ../BSP/POWER/: power.c
    ../BSP/KT6328/: KT6328.c
    ../BSP/BL24C02/: BL24C02.c DataSave.c
    ../BSP/AHT21/: AHT21.c
    ../BSP/EM7028/: em70x8.c
    ../BSP/LSM303DLH/: LSM303.c
    ../BSP/MPU6050/: mpu6050.c
  group SYSTEM
    ../SYSTEM/: delay.c delay.h sys.h
  group USER
    ../User/Soft_Timer/: soft_timer.c soft_timer_us.c
  group USER/WatchFace
    ../User/WatchFace/: watch_face.c watch_face.h
  group USER/Device
    ../User/Device/: device_manager.c battery_manager.c ble_manager.c history_manager.c device_manager.h
  group USER/Pages
    ../User/Pages/: sensor_pages.c battery_page.c history_page.c sensor_pages.h settings_page.c settings_page.h calculator_page.c calculator_page.h stopwatch_page.c stopwatch_page.h about_page.c about_page.h notification_manager.c notification_manager.h notification_page.c notification_page.h
  group USER/Power
    ../User/Power/: power_manager.c power_manager.h
  group USER/App
    ../User/App/: app_ui.c status_bar.c app_ui.h menu_page.c menu_page.h date_setting_page.c date_setting_page.h time_setting_page.c time_setting_page.h menu_icons.h
    ../User/App/Fonts/: ui_font_iconfont30.c ui_font_iconfont34.c
  group ThirdParty/LVGL/GUI
    ../ThirdParty/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../ThirdParty/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../ThirdParty/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../ThirdParty/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../ThirdParty/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../ThirdParty/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../ThirdParty/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../ThirdParty/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../ThirdParty/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../ThirdParty/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../ThirdParty/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../ThirdParty/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../ThirdParty/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../ThirdParty/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
  group ThirdParty/LVGL/GUI_Port
    ../ThirdParty/LVGL/GUI/porting/: lv_port_disp.c lv_port_indev.c
software components: CMSIS:CORE 4.3.0
