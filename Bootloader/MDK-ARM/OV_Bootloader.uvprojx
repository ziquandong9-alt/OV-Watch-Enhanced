# Keil uVision project OV_Bootloader.uvprojx, settings and files
target OV_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OV_Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,uECC_PLATFORM=0,uECC_WORD_SIZE=4,uECC_OPTIMIZATION_LEVEL=2,uECC_SUPPORTS_secp160r1=0,uECC_SUPPORTS_secp192r1=0,uECC_SUPPORTS_secp224r1=0,uECC_SUPPORTS_secp256k1=0,uECC_SUPPORT_COMPRESSED_POINT=0,uECC_VLI_NATIVE_LITTLE_ENDIAN=0
  c include: ../Inc;../ThirdParty/micro-ecc;../ThirdParty/tinycrypt/include;../../Core/Inc;../../BSP/LCD;../../Drivers/STM32F4xx_HAL_Driver/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Bootloader
    ../Src/: main.c boot_hal.c boot_crc32.c boot_crypto.c boot_protocol.c boot_display.c
  group Crypto
    ../ThirdParty/micro-ecc/: uECC.c
    ../ThirdParty/tinycrypt/source/: sha256.c utils.c
  group CMSIS
    ../../MDK-ARM/: startup_stm32f411xe.s
    ../../Core/Src/: system_stm32f4xx.c
  group STM32 HAL
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c
software components: CMSIS:CORE 4.3.0
